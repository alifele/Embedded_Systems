# Keil uVision project test.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_CL, USE_STDPERIPH_DRIVER
  c include: ..\ALI3;.\lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./: startup_stm32f10x_hd.s main.c
  group CMSIS
    ./: system_stm32f10x.c
  group CMSIS Driver
    ./lib/: stm32f10x_gpio.c stm32f10x_rcc.c
